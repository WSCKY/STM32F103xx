# Keil uVision project Project.uvprojx, settings and files
target Self-Balance (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SelfBalance
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --C99
  c include: ..\inc;..\..\Libraries\CMSIS\CoreSupport;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\SystemConfig;..\..\FreeRTOS\include;..\..\FreeRTOS\CMSIS_RTOS;..\..\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../src/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_can.c
  group CMSIS
    ../../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../src/: system_stm32f10x.c
  group MDK-ARM
    ../../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group Hardware
    ../src/: LED.c Debug.c Button.c Encoder.c TOF.c Battery.c MotorDriver.c mpu6500.c CAN.c RemoteController.c FreeControl.c
  group Middlewares
    ../src/: AttitudeEstimator.c MainCtrl.c DataMonitor.c pidController.c AttitudeController.c SpeedController.c YawController.c CRC16.c Maths.c VoltageCheck.c SensorGroup.c CommProtocol.c AppsDataProc.c SignalProcess.c Indicator.c CtrlArbitration.c
  group SystemConfig
    ../SystemConfig/: SysConfig.h
  group FreeRTOS
    ../../FreeRTOS/: list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/CMSIS_RTOS
    ../../FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group readme
    ../: rec.txt
software components: CMSIS:CORE 5.0.1
